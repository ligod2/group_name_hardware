# Keil uVision project 例程3-串口通信.uvproj, settings and files
target 例程3-串口通信 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 例程3-串口通信 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\..\software\mdk5\C51\INC;src;src\inc
  group SRC
    src/: main.c MyEsp8266.c MyTime.c MyUART.c
